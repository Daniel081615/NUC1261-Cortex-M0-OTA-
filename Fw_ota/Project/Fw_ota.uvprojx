# Keil uVision project Fw_ota.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: NUC1261NE4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Fw_ota
  AfterMake: fromelf --bin ".\objects\@L.axf" --output ".\objects\@L.bin"
  AfterMake: fromelf --text -c ".\objects\@L.axf" --output ".\objects\@L.txt"
  c flags: uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Library\StdDriver\inc;..\..\Library\Device\Nuvoton\NUC1261\Include
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
    ../../Library/Device/Nuvoton/NUC1261/Source/ARM/: startup_NUC1261.s
  group USER
    ../Fw_App_OTA_Package/: main.c crc_util.c fmc_user.c fw_metadata.c fw_ota_mark_setup.c fw_selfcheck.c fw_status.c uart_comm.c uart_user.c wdt_user.c
  group Library
    ../../Library/StdDriver/src/: crc.c fmc.c wdt.c
software components: CMSIS:CORE 6.1.0
