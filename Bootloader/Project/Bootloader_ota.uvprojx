# Keil uVision project Bootloader_ota.uvprojx, settings and files
target ISP_UART (6230000::V6.23::ARMCLANG)
  device: NUC1261NE4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Bootloader_ota
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Library\Device\Nuvoton\NUC1261\Include;..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
    ../../Library/Device/Nuvoton/NUC1261/Source/ARM/: startup_NUC1261.s
  group User
    ../Bootloader_IAP/: main.c isp_user.c fw_metadata.c fmc_user.c Select_fw.c uart_transfer.c targetdev.c crc_user.c isp_user.h fw_metadata.h fmc_user.h Select_fw.h uart_transfer.h targetdev.h crc_user.h
  group Library
    ../../Library/StdDriver/src/: crc.c fmc.c wdt.c
software components: CMSIS:CORE 6.1.0
